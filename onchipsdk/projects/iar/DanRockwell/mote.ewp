# IAR project mote.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: --enum_is_int; --no_wchar
  ICCARM.PreInclude: ..\all_projects.iarinc
  ICCARM.CCIncludePath2: ..\..\..\src\app\DanRockwell\src\; ..\..\..\src\app\DanRockwell\inc\; ..\..\..\src\app\common\; ..\..\..\src\inc\; ..\..\..\src\modules\clilib\; ..\..\..\src\modules\ip_applib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mote.srec
  postbuild: C:\Python27\python.exe "..\..\..\tools\dustElfToBin\dustElfToBin.py" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: use_loader=1
  ILINK.IlinkIcfFile: ..\..\..\tools\linker_configuration\Eterna.icf
  ILINK.IlinkProgramEntryLabel: __reset_handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app/inc
    ../../../src/app/DanRockwell/inc/: alarm.h app_common.h app_task_cfg.h battery.h calibration.h config.h debug.h flash.h gpio.h ltc2984.h ltc2984_cfg.h moteapp.h radio.h report.h spi.h spline.h time.h version.h
  group app/src
    ../../../src/app/DanRockwell/src/: alarm.c battery.c calibration.c config.c debug.c display.c flash.c fwupdate.c gpio.c initsys.c ltc2984.c moteapp.c radio.c report.c security.c spi.c spline.c temperature.c time.c
  group common
    ../../../src/app/common/: app_cfg.h build.h cli_task.c cli_task.h loc_task.c loc_task.h Ver.h well_known_ports.h
  group inc
    ../../../src/inc/: dn_adc.h dn_api_common.h dn_api_local.h dn_api_param.h dn_channel.h dn_cli.h dn_common.h dn_errno.h dn_exe_hdr.h dn_flash_drv.h dn_flash_info.h dn_fs.h dn_gpio.h dn_hwinfo.h dn_i2c.h dn_lptimer.h dn_mem.h dn_mesh.h dn_mesh_const.h dn_onewire.h dn_pack.h dn_pwm.h dn_radio.h dn_randhw.h dn_security.h dn_spi.h dn_system.h dn_temperature.h dn_time.h dn_typedef.h dn_uart.h dn_uart_raw.h os_cfg.h os_cpu.h ucos_ii.h
  group lib
    ../../../src/lib/: libip_stack.a libucos_full.a
  group modules/clilib
    ../../../src/modules/clilib/: dnm_ucli.c dnm_ucli.h
  group modules/ip_applib
    ../../../src/modules/ip_applib/: dnm_local.c dnm_local.h dnm_rate_ctrl.c dnm_rate_ctrl.h dnm_service.c dnm_service.h
